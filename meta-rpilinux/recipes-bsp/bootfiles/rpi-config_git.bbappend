do_deploy:append:raspberrypi4-64() {
	echo "arm_64bit=1" >> $CONFIG
}
